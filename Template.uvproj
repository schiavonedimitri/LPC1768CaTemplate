# Keil uVision project Template.uvproj, settings and files
target Template (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Template
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group System
    ./System/: core_cm3.c startup_LPC17xx.s system_LPC17xx.c
  group Main
    ./Main/: main.c
  group Button
    ./Button/: button.h irqButton.c libButton.c
  group Led
    ./Led/: functLed.c led.h libLed.c
  group Joystick
    ./Joystick/: functJoystick.c joystick.h libJoystick.c
  group Timer
    ./Timer/: irqTimer.c libTimer.c timer.h
  group Rit
    ./Rit/: irqRit.c libRit.c rit.h
